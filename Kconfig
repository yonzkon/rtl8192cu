## Kconfig
```kconfig
config RTL8192CU
	tristate "Realtek 8192C USB WiFi"
	depends on USB && CFG80211_WEXT
	---help---
	  Help message of RTL8192CU
```
